<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>C:\my_projects\166.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\BKY3200D_AI.ewp</path>
    </project>
    <batchBuild />
</workspace>
